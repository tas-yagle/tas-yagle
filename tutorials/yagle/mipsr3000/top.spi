.temp 25
.option tnom=25
.include ../techno/bsim4_dummy.hsp
.include mips_chip.spi
